# Keil uVision project Ultrasonic.uvprojx, settings and files
target Ultrasonic (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Ultrasonic +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE
  c include: ../Inc;                                                 ../Drivers/STM32F3xx_HAL_Driver/Inc;                                                 ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                                                 ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                                                 ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
